# IAR project i2c_loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100AN series Nuvoton Nano100AN series (Nano100AN,Nano110AN,Nano120AN,Nano130AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c_loopback.bin
  ILINK.IlinkOutputFile: i2c_loopback.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c retarget.c sys.c timer.c uart.c
  group User
    ../: interfacergbled.c inwallactions.c inwallbutton.c inwallcolours.h inwallconstants.h inwallI2C.c inwalluart.c main.c
